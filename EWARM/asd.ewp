# IAR project asd.ewp, settings and files
configuration asd (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VE ST STM32F207VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F207xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc; ../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F2xx/Include; ../Drivers/CMSIS/Include; D:\Code\qwer\flash; D:\Code\qwer\RS485; D:\Code\qwer\ADC; D:\Code\qwer\Peripheral\Inc; D:\Code\qwer\Modbus
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: asd.hex
  ILINK.IlinkOutputFile: asd.out
  ILINK.IlinkIcfFile: stm32f207xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ADC
    ../ADC/: ADC.c ADC.h
  group Application/EWARM
    ./: startup_stm32f207xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f2xx_hal_msp.c stm32f2xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_uart.c
  group Flash
    ../flash/: flash.c flash.h
  group Modbus
    ../Modbus/: ModbusRTU_Slave.c ModbusRTU_Slave.h
  group RS485
    ../RS485/: RS485.c RS485.h
